options:
  parameters:
    author: Alexandru Csete http://oz9aec.net
    category: Custom
    description: 2 channel AIS receiver to be used with gnuais
    generate_options: qt_gui
    id: ais_rx
    output_language: python
    title: AIS receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: xlate_filter_taps
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, 15000, 20000, firdes.WIN_HAMMING, 6.76)
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '0.3'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '0.3'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/nivole/Documents/grcSchmeAIS/outAIS/outfile
    type: short
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '16000'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '16000'
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: short
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-25e3'
    decim: '20'
    samp_rate: samp_rate
    taps: xlate_filter_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 25e3
    decim: '20'
    samp_rate: samp_rate
    taps: xlate_filter_taps
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    corr0: '104'
    freq0: 162e6
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 162e6
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: samp_rate
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_TAG
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_TAG
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 162e6
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_1, '0']
- [analog_quadrature_demod_cf_0_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_float_to_short_0, '0', blocks_interleave_0, '1']
- [blocks_float_to_short_0_0, '0', blocks_interleave_0, '0']
- [blocks_interleave_0, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', blocks_float_to_short_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_float_to_short_0_0, '0']

metadata:
  file_format: 1
